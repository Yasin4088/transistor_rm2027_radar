options:
  parameters:
    author: EGO
    generate_options: qt_gui
    id: RM
    output_language: python
    title: RM
  states: {}

blocks:
- name: BT
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: BW
  id: variable
  parameters:
    value: '540000'
  states: {state: disabled}
- name: BW_ganrao
  id: variable
  parameters:
    comment: |-
      pluto干扰源带宽选择（自动换算频偏和发送灵敏度）
      干扰源一：bw1
      干扰源二：bw2
      干扰源三：bw3
    value: bw3
  states: {}
- name: F
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: 最大频偏
    rangeType: int
    start: '200000'
    step: '1000'
    stop: '1000000'
    value: int(samp_rate/sps)
  states: {state: disabled}
- name: Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: x-3,0,1,4
    label: 接收增益
    start: '10'
    step: '1'
    stop: '71'
    value: '50'
  states: {state: disabled}
- name: LowPass
  id: variable_qtgui_range
  parameters:
    gui_hint: x-1,2,1,2
    label: 低通滤波器带宽
    start: '10000'
    step: '1000'
    stop: sample_rate/2
    value: sample_rate/2
  states: {state: disabled}
- name: SOF
  id: variable
  parameters:
    value: '0xA5'
  states: {}
- name: X
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,2
    label: 频偏系数
    start: '2'
    step: '0.1'
    stop: '6'
    value: '4.1'
  states: {state: disabled}
- name: access_ganraobo
  id: variable
  parameters:
    value: '[0x16, 0xE8, 0xD3, 0x77, 0x15, 0x1C, 0x71, 0x2D]'
  states: {}
- name: access_xinxibo
  id: variable
  parameters:
    value: '[0x2F, 0x6F, 0x4C, 0x74, 0xB9, 0x14, 0x49, 0x2E]'
  states: {}
- name: attend_gb
  id: variable_qtgui_range
  parameters:
    gui_hint: x,2,1,2
    label: 广播源衰减（dB）
    start: '10'
    step: '0.25'
    stop: '89.75'
    value: '50'
  states: {state: disabled}
- name: attend_gr
  id: variable_qtgui_range
  parameters:
    gui_hint: x,0,1,2
    label: 干扰源衰减（dB）
    start: '10'
    step: '0.25'
    stop: '89.75'
    value: '12.5'
  states: {}
- name: bw
  id: variable_qtgui_chooser
  parameters:
    gui_hint: x+1,0,1,2
    label: 干扰源带宽选择
    label0: 干扰源一
    label1: 干扰源二
    label2: 干扰源三
    num_opts: '3'
    option0: '940000'
    option1: '860000'
    option2: '250000'
    orient: Qt.QHBoxLayout
    type: int
    value: '940000'
    widget: radio_buttons
  states: {state: disabled}
- name: bw1
  id: variable
  parameters:
    value: '940000'
  states: {}
- name: bw2
  id: variable
  parameters:
    value: '860000'
  states: {}
- name: bw3
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: bw_re
  id: variable_qtgui_chooser
  parameters:
    gui_hint: x,2,1,1
    label: 接收pluto滤波带宽选择
    label0: 干扰源1
    label1: 干扰源2
    label2: 干扰源3
    label3: 广播源
    num_opts: '4'
    option0: '940000'
    option1: '860000'
    option2: '250000'
    option3: '540000'
    type: int
    value: '940000'
  states: {state: disabled}
- name: cen_f
  id: variable_qtgui_chooser
  parameters:
    label: 中心频点
    num_opts: '3'
    option0: '0'
    option1: '1'
    option2: '2'
    type: int
    value: '0'
  states: {state: disabled}
- name: cen_f
  id: variable_qtgui_range
  parameters:
    gui_hint: x-1,0,1,2
    label: 接收端的中心频点
    start: '432200000'
    step: '10000'
    stop: '433200000'
    value: '433200000'
  states: {state: disabled}
- name: center_F
  id: variable
  parameters:
    value: '433200000'
  states: {state: disabled}
- name: center_F_ganrao
  id: variable
  parameters:
    value: center_f
  states: {}
- name: center_f
  id: variable_qtgui_chooser
  parameters:
    gui_hint: x,2,1,2
    label: 干扰源中心频点选择
    label0: 干扰源一
    label1: 干扰源二
    label2: 干扰源三
    num_opts: '3'
    option0: '432200000'
    option1: '432500000'
    option2: '432800000'
    orient: Qt.QHBoxLayout
    type: int
    value: '432200000'
    widget: radio_buttons
  states: {}
- name: cmd_id
  id: variable
  parameters:
    value: '[0x0A,0x01]'
  states: {}
- name: data
  id: variable
  parameters:
    value: '6'
  states: {}
- name: repeat
  id: variable
  parameters:
    value: '1'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sen
  id: variable
  parameters:
    value: 2*math.pi*to_F/sample_rate
  states: {state: disabled}
- name: sen_ganrao
  id: variable
  parameters:
    value: 2*math.pi*to_F_ganrao/sample_rate
  states: {}
- name: sen_re
  id: variable_qtgui_chooser
  parameters:
    gui_hint: x,3,1,1
    label: 接收灵敏度选择
    label0: 干扰源1
    label1: 干扰源2
    label2: 干扰源3
    label3: 广播源
    num_opts: '4'
    option0: '2.8194'
    option1: '2.5681'
    option2: '0.6517'
    option3: '1.5628'
    type: real
    value: '2.8194'
  states: {state: disabled}
- name: sps
  id: variable
  parameters:
    value: '47'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: sample_rate/sps
  states: {}
- name: to_F
  id: variable
  parameters:
    value: BW/2-symbol_rate
  states: {state: disabled}
- name: to_F_ganrao
  id: variable
  parameters:
    value: BW_ganrao/2-symbol_rate
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    step_size: '.0001'
    type: lms
  states: {state: disabled}
- name: x
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.PMT_T
    period: '10'
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      将 N 个流作为输入。每个流都标有数据包长度。数据包从每个输入流顺序输出。
      输出信号具有新的长度标签，它是所有单独长度标签的总和。旧的长度标签将被丢弃。
    lengthtagname: packet_len
    ninputs: '3'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      将 N 个流作为输入。每个流都标有数据包长度。数据包从每个输入流顺序输出。
      输出信号具有新的长度标签，它是所有单独长度标签的总和。旧的长度标签将被丢弃。
    lengthtagname: packet_len
    ninputs: '3'
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: 要是这玩意消耗样本的数量小于接收到的样本数量过大会死机。。。
    samples_per_second: 27*1000
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    comment: 要是这玩意消耗样本的数量小于接收到的样本数量过大会死机。。。
    samples_per_second: 27*500
    type: byte
  states: {}
- name: blocks_uchar_to_float_2_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_2_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_2_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: 包头
    repeat: 'True'
    tags: ''
    type: byte
    vector: '[0xA5, ]'
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: header
    repeat: 'True'
    tags: ''
    type: byte
    vector: '[0x00]*4+[0xA5,0x00,0x16,0x01,0xC6]+[0x00]*4'
  states: {state: disabled}
- name: button
  id: variable_qtgui_msg_push_button
  parameters:
    label: 消息发送
    msgName: pressed
    type: int
    value: '1'
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
    sensitivity: sen_re
  states: {state: disabled}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: BT
    samples_per_symbol: sps
    sensitivity: sen
  states: {state: disabled}
- name: digital_gfsk_mod_0_0
  id: digital_gfsk_mod
  parameters:
    bt: BT
    comment: 这个sen灵敏度没办法在运行的时候改，只能改完再重开
    samples_per_symbol: sps
    sensitivity: sen_ganrao
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: attend_gb
    bandwidth: BW
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_F)
    rf_port_select: '''A'''
    samplerate: int(sample_rate)
    tx1_en: 'True'
    tx2_en: 'False'
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_fmcomms2_sink_0_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: attend_gr
    bandwidth: BW_ganrao
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_F_ganrao)
    rf_port_select: '''A'''
    samplerate: int(sample_rate)
    tx1_en: 'True'
    tx2_en: 'False'
    type: fc32
    uri: ip:192.168.1.10
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: attend_gb
    bandwidth: BW
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_F)
    samplerate: int(sample_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: bw_re
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(cen_f)
    gain1: '''manual'''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(sample_rate)
    type: fc32
    uri: ip:192.168.1.10
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: jiang_0
  id: jiang
  parameters:
    Access_Code: access_ganraobo
    Period: '100'
    com_id: cmd_id
    comment: 5+包长+4字节
    payload_size: data
  states: {}
- name: jiang_0_0
  id: jiang
  parameters:
    Access_Code: access_xinxibo
    Period: '100'
    com_id: cmd_id
    comment: 5+包长+4字节
    payload_size: data
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: LowPass
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: '20000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: note_1
  id: note
  parameters:
    comment: |-
      这个流图是干扰源一二三的发送
      1.发送之前确认带宽选对了就行
      接收参数设置：
      1.发送衰减
      2.信号投放的频点
      是哪个干扰就在qt窗口设置在哪个频点就行了，发送衰减就根据机型给个大概，
      有pa就给大一点，没pa就小一点。但还是建议整个频谱分析仪或者其他的功率测试设备，
      测一个准确的-10dBm对应的衰减，给大了广播源就毛都没有了
    note: 干扰源发送
  states: {}
- name: pad_sink_0_0_0_0
  id: pad_sink
  parameters:
    label: buling
    type: message
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_1
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_1_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xff'
    maxsize: '1000'
    minsize: '1000'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: center_F*0
    fftsize: '4096'
    grid: 'True'
    name: '"广播源发送频谱"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: center_F_ganrao*0
    fftsize: '4096'
    grid: 'True'
    gui_hint: x+3,0,1,2
    name: '"干扰源发送频谱"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate*4
    fc: cen_f
    fftsize: '8192'
    grid: 'True'
    gui_hint: 3+x,2,1,2
    name: '"接收频谱"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: 调制前波形
    size: 1024*4
    srate: sample_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1+x,0,1,2
    name: '"广播源发送调制后的基带信号"'
    size: 1024*1
    srate: 500000*2
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_1_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: x+2,0,1,2
    name: '"干扰源发送调制后的基带信号"'
    size: 1024*1
    srate: 500000*2
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_4
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"发送端二进制信号"'
    size: (data+9)*10
    srate: sample_rate
    stemplot: 'True'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: float
    ymax: '12'
    ymin: '-12'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_4_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 4+x,0,1,4
    name: '"接收端二进制信号"'
    size: (data+9)*100
    srate: sample_rate
    stemplot: 'True'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: float
    ymax: '12'
    ymin: '-12'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_4_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: x+2,2,1,2
    name: '"发送端二进制信号"'
    size: (data+9)*10
    srate: sample_rate
    stemplot: 'True'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: float
    ymax: '12'
    ymin: '-12'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate*4
    fc: cen_f
    fftsize: '4096'
    gui_hint: 3+x,0,1,2
    name: '"接收瀑布图"'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: center_F*0
    fftsize: '4096'
    name: '"广播源发送瀑布图"'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: center_F_ganrao*0
    fftsize: '4096'
    grid: 'True'
    gui_hint: x+3,2,1,2
    name: '"干扰源发送瀑布图"'
    type: complex
  states: {}
- name: rx_mod_payload
  id: virtual_source
  parameters:
    stream_id: llll
  states: {state: disabled}
- name: rx_mod_payload_0
  id: virtual_source
  parameters:
    stream_id: byt_out_g
  states: {state: disabled}
- name: rx_mod_payload_0_0
  id: virtual_source
  parameters:
    stream_id: byt_out
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1.0'
    type: complex
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: byt_out
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: byt_out
  states: {state: disabled}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: byt_out_g
  states: {state: disabled}

connections:
- [analog_random_source_x_0, '0', virtual_sink_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', virtual_sink_0_0_1, '0']
- [blocks_throttle2_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_throttle2_0, '0', digital_gfsk_mod_0, '0']
- [blocks_throttle2_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [blocks_throttle2_0_0, '0', digital_gfsk_mod_0_0, '0']
- [blocks_uchar_to_float_2_0, '0', qtgui_time_sink_x_0_1_4, '0']
- [blocks_uchar_to_float_2_0_0, '0', qtgui_time_sink_x_0_1_4_0, '0']
- [blocks_uchar_to_float_2_0_1, '0', qtgui_time_sink_x_0_1_4_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_2_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_uchar_to_float_2_0_1, '0']
- [blocks_vector_source_x_0, '0', virtual_sink_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', virtual_sink_0_0_0, '0']
- [digital_gfsk_demod_0, '0', blocks_uchar_to_float_2_0_0, '0']
- [digital_gfsk_mod_0, '0', iio_fmcomms2_sink_0, '0']
- [digital_gfsk_mod_0, '0', iio_pluto_sink_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0_1_1_1, '0']
- [digital_gfsk_mod_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [digital_gfsk_mod_0_0, '0', iio_fmcomms2_sink_0_0, '0']
- [digital_gfsk_mod_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_gfsk_mod_0_0, '0', qtgui_time_sink_x_0_1_1_1_0, '0']
- [digital_gfsk_mod_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [jiang_0, access, pdu_pdu_to_tagged_stream_0_0, pdus]
- [jiang_0, header, blocks_message_debug_0, print_pdu]
- [jiang_0, header, pdu_pdu_to_tagged_stream_1, pdus]
- [jiang_0, payload, blocks_message_debug_0, print_pdu]
- [jiang_0, payload, pdu_pdu_to_tagged_stream_0, pdus]
- [jiang_0_0, access, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [jiang_0_0, header, pdu_pdu_to_tagged_stream_1_0, pdus]
- [jiang_0_0, payload, pdu_pdu_to_tagged_stream_0_1, pdus]
- [low_pass_filter_0, '0', digital_gfsk_demod_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '2']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_1, '0', blocks_tagged_stream_mux_0_0, '2']
- [pdu_pdu_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_1_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [rx_mod_payload, '0', low_pass_filter_0, '0']
- [rx_mod_payload_0, '0', blocks_throttle2_0, '0']
- [rx_mod_payload_0_0, '0', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
