options:
  parameters:
    generate_options: hb
    id: jiang
    output_language: python
    title: block
  states: {}

blocks:
- name: SOF
  id: variable
  parameters:
    comment: |-
      数据帧
      起始字节
      固定0xA5
    value: '0xA5'
  states: {}
- name: data
  id: variable
  parameters:
    comment: '[payload_size]位数据'
    value: '[random.getrandbits(8) for i in range(payload_size)]'
  states: {}
- name: header
  id: variable
  parameters:
    comment: |-
      frame_header
      没加crc
      4字节
    value: '[SOF,0x00,payload_size,seq]'
  states: {}
- name: kongkou
  id: variable
  parameters:
    value: Access_Code + [0x00, 0x0f, 0x00, 0x0f]
  states: {}
- name: payload
  id: variable
  parameters:
    comment: |-
      数据段
      也没加crc
      2+nbyte
    value: com_id+data
  states: {}
- name: seq
  id: variable
  parameters:
    comment: 包序号
    value: '0x01'
  states: {}
- name: Access_Code
  id: parameter
  parameters:
    label: 前导码
    value: '[0x2F, 0x6F, 0x4C, 0x74, 0xB9, 0x14, 0x49, 0x2E]'
  states: {}
- name: Period
  id: parameter
  parameters:
    label: 触发频率(ms)
    type: intx
    value: '10'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: 4字节
    msg: pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(4,header))
    period: Period
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    comment: 2+包长字节
    msg: pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(8,payload))
    period: Period
  states: {}
- name: blocks_message_strobe_0_1
  id: blocks_message_strobe
  parameters:
    comment: 12字节
    msg: pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(12,kongkou))
    period: Period
  states: {}
- name: com_id
  id: parameter
  parameters:
    label: 命令码
    value: '[0x0A,0x01]'
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    comment: +1字节
    final_xor: '0x00'
    initial_value: '0xFF'
    input_reflected: 'False'
    num_bits: '8'
    poly: '0x31'
    result_reflected: 'False'
  states: {}
- name: digital_crc_append_0_0
  id: digital_crc_append
  parameters:
    comment: +2字节
    final_xor: '0x0000'
    initial_value: '0xFFFF'
    input_reflected: 'False'
    num_bits: '16'
    poly: '0x1189'
    result_reflected: 'False'
    swap_endianness: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: from cmath import exp, pi
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: header
    type: message
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: payload
    type: message
  states: {}
- name: pad_sink_0_0_1
  id: pad_sink
  parameters:
    label: access
    type: message
  states: {}
- name: payload_size
  id: parameter
  parameters:
    label: 包长
    value: '6'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, digital_crc_append_0, in]
- [blocks_message_strobe_0_0, strobe, digital_crc_append_0_0, in]
- [blocks_message_strobe_0_1, strobe, pad_sink_0_0_1, in]
- [digital_crc_append_0, out, pad_sink_0_0, in]
- [digital_crc_append_0_0, out, pad_sink_0_0_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
